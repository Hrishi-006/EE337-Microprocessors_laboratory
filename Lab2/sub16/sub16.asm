// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL SUB16
HERE: SJMP HERE
ORG 130H
// *****************
SUB16:
// ADD YOUR CODE HERE
// Perform x - y using 2's complement and ADD16
CLR C
CLR A
MOV B,#00H


MOV A, 73H
CPL A
ADD A, #01H
MOV R1,A

MOV A,72H
CPL A
ADDC A,#00H
MOV R0,A

CLR C

MOV A, 71H
ADD A,R1
MOV 76H,A

MOV A,70H
ADDC A,R0
MOV 75H,A

CLR A
ADDC A,#00H
MOV 74H,A


RET
END